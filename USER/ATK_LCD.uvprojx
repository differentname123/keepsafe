# Keil uVision project ATK_LCD.uvprojx, settings and files
target ATK_LCD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ATK_LCD +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L475xx
  c include: ..\USER;..\CORE;..\HALLIB\STM32L4xx_HAL_Driver\Inc;..\HALLIB\STM32L4xx_HAL_Driver\Inc\Legacy;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\BEEP;..\HARDWARE\EXTI;..\HARDWARE\IWDG;..\HARDWARE\WWDG;..\HARDWARE\TIMER;..\HARDWARE\PWM;..\HARDWARE\LCD;..\HARDWARE\SPI3;..\HARDWARE\OV7725;..\ESP8266;..\HARDWARE\MALLOC;..\HARDWARE\RC522;..\HARDWARE\BEEP;..\HARDWARE\AHT10;..\HARDWARE\MYIIC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group USER
    ./: main.c stm32l4xx_it.c system_stm32l4xx.c
  group CORE
    ../CORE/: cmsis_armcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32l475xx.s
  group HALLIB
    ../HALLIB/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_spi.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/usart/: usart.c usart.h
  group HARDWARE
    ../HARDWARE/LED/: led.c led.h
    ../HARDWARE/LCD/: lcd.c lcd.h
    ../HARDWARE/SPI3/: spi3.c spi3.h
    ../HARDWARE/OV7725/: ov7725.c sccb.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MALLOC/: malloc.c malloc.h
    ../HARDWARE/RC522/: RC522.c RC522.h
    ../HARDWARE/BEEP/: beep.c beep.h
    ../HARDWARE/AHT10/: aht10.c aht10.h
    ../HARDWARE/MYIIC/: myiic.c myiic.h
  group README
    ../: readme.txt
  group ESP8266
    ../ESP8266/: wifiap.c wifiap.h wifista.c
